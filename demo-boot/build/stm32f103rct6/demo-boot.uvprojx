# Keil uVision project demo-boot.uvprojx, settings and files
target demo-boot (ARM-ADS)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000-0x2000BFFF) IROM(0x8000000-0x803FFFF)  CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: VDS-CTRL-BOOT +hex
  AfterMake: fromelf.exe --bin -o ./Objects/vds-ctrl-boot.bin ./Objects/vds-ctrl-boot.axf
  c flags: Optim=4 OneElfS=1 uC99=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F103xE,USE_HAL_DRIVER,STM32F103xE
  c include: ..\..\source;..\..\source\common\inc;..\..\source\fal\inc;..\..\source\hal\BSP\hal_config;..\..\source\hal\BSP\Inc;..\..\source\hal\FWLIB\CMSIS;..\..\source\hal\FWLIB\CMSIS\Include;..\..\source\hal\FWLIB\STM32F1xx_HAL_Driver\Inc\Legacy;..\..\source\hal\FWLIB\STM32F1xx_HAL_Driver\Inc;..\..\source\pal\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group FWLIB
    ../../source/hal/FWLIB/CMSIS/: system_stm32f1xx.c
    ../../source/hal/FWLIB/CMSIS/startup/: startup_stm32f103xe.s
    ../../source/hal/FWLIB/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal.c stm32f1xx_hal_gpio.c stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_i2c.c stm32f1xx_hal_spi.c stm32f1xx_hal_spi_ex.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_uart.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_dma.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_cortex.c
  group COMMON
    ../../source/common/src/: public.c RingBuffer.c
  group HAL
    ../../source/hal/BSP/hal_config/: stm32f1xx_hal_msp.c stm32f1xx_it.c
    ../../source/hal/BSP/Src/: BSP.c gpio.c tim.c usart.c
  group FAL
    ../../source/fal/src/: fal.c task.c cpuFlash.c update.c
  group PAL
    ../../source/pal/src/: pal.c gxxServer.c
  group APP
    ../../source/: main.c
